# IAR project UXO_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD
  ICCARM.CCIncludePath2: App; Bsp; Libraries\CMSIS\DeviceSupport; Libraries\CMSIS\DeviceSupport\startup; Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ExecutableFile.hex
  ILINK.IlinkOutputFile: UXO_Demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    App/: common.h main.c stm32f10x_it.c
  group Bsp
    Bsp/: ad7606_spi.c bsp.c spi.c time.c
  group CMSIS
    Libraries/CMSIS/DeviceSupport/: system_stm32f10x.c
  group Doc
    Doc/: ReadMe.txt
  group Startup Code
    Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f10x_hd.s
  group STM32F10x_StdPeriph_Driver
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
